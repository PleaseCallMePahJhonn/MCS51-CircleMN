# Keil uVision project Exti0AndLedFlash.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Exti0AndLedFlash +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\EXTI;
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./EXTI/: exti.c
